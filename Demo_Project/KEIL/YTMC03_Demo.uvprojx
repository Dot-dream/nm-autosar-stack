# Keil uVision project YTMC03_Demo.uvprojx, settings and files
target YTMC03_Demo (6140000::V6.14::ARMCLANG)
  device: YTM32B1MC03 YTMicro
  pack: YTMicro.YTM32B1MC0_DFP.1.3.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M33") CLOCK(12000000) ELITTLE
  output: YTMC03_Demo +hex
  AfterMake: fromelf --bin --bincombined --output=Objects\@L.bin !L
  AfterMake: fromelf --m32 --m32combined --output=Objects\@L.srec !L
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: YTM32B1MC0,CPU_YTM32B1MC0,
  c include: ../board;../platform/drivers/src/clock/YTM32B1Mx;../platform/drivers/src/pins;../platform/drivers/src/dma;../platform/drivers/src/flexcan;../platform/drivers/src/mpwm;../platform/drivers/src/uart;../platform/drivers/inc;../platform/devices/common;../platform/devices;../platform/devices/YTM32B1MC0/include;../platform/devices/YTM32B1MC0/startup;../CMSIS/Core/Include;../rtos/osif;../middleware/utility_print/printf;..\middleware\utility_print\log;..\middleware\utility_print;..\Bsp\Hal\bsp_gpio_hal;..\Bsp\Middleware\bsp_gpio_mw;..\Bsp\Hal\bsp_can_hal;..\Bsp\Middleware\bsp_can_mw;../platform/drivers/src/lptmr;..\middleware\library\Taske;..\app\Config;..\app\Modules;..\app\System;..\middleware\NM;..\middleware\NM\CanNm;..\middleware\NM\Nm_Timer;..\middleware\NM\OsIf;..\middleware\library\ebtn;
  asm include: ../board;../platform/drivers/src/clock/YTM32B1Mx;../platform/drivers/src/pins;../platform/drivers/src/dma;../platform/drivers/src/flexcan;../platform/drivers/src/mpwm;../platform/drivers/src/uart;../platform/drivers/inc;../platform/devices/common;../platform/devices;../platform/devices/YTM32B1MC0/include;../platform/devices/YTM32B1MC0/startup;../CMSIS/Core/Include;../rtos/osif;../middleware/utility_print/printf;../platform/drivers/src/lptmr;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../board/yt_linker.scf
  link misc: --entry Reset_Handler --no_startup --diag_suppress=L6314W,L6221E,L6329W --keep=*(.isr_vector)
  group app
    ../app/: main.c
    ../app/Modules/: module_event.c module_led.c module_log.c module_can.c module_nm.c module_nm_callback.c
    ../app/System/: scheduler.c nm_platform.c
    ../app/Config/: Nm_Lcfg.c
  group board
    ../board/: clock_config.c clock_config.h pin_mux.c pin_mux.h RamInit0.S RamInit1.c RamInit2.c startup.S vector.S vector_table_copy.c interrupt_config.c interrupt_config.h dma_config.c dma_config.h can_config.c can_config.h lptmr_config.c lptmr_config.h mpwm_config.c mpwm_config.h uart_config.c uart_config.h lin_config.c lin_config.h utility_print_config.h utility_print_config.c sdk_project_config.h
  group platform
    ../platform/drivers/src/clock/YTM32B1Mx/: cfmu_hw_access.h clock_YTM32B1Mx.c clock_YTM32B1Mx.h cmu_hw_access.h ipc_hw_access.h scu_hw_access.h
    ../platform/drivers/inc/: clock.h clock_manager.h pins_driver.h interrupt_manager.h dma_driver.h flexcan_driver.h lptmr_driver.h mpwm_common.h mpwm_pwm_driver.h lin_driver.h uart_driver.h
    ../platform/drivers/src/pins/: pins_driver.c pins_gpio_hw_access.h pins_port_hw_access.c pins_port_hw_access.h
    ../platform/devices/common/: core_common.h
    ../platform/devices/: callbacks.h devassert.h device_registers.h floats.h status.h
    ../platform/devices/YTM32B1MC0/include/: YTM32B1MC0.h YTM32B1MC0_features.h
    ../platform/devices/YTM32B1MC0/startup/: system_YTM32B1MC0.c system_YTM32B1MC0.h
    ../platform/drivers/src/interrupt/: interrupt_manager.c
    ../platform/drivers/src/dma/: dma_driver.c dma_hw_access.c dma_hw_access.h dma_irq.c dma_irq.h
    ../platform/drivers/src/flexcan/: flexcan_driver.c flexcan_hw_access.c flexcan_hw_access.h flexcan_irq.c flexcan_irq.h
    ../platform/drivers/src/lptmr/: lptmr_driver.c lptmr_hw_access.c lptmr_hw_access.h
    ../platform/drivers/src/mpwm/: mpwm_common.c mpwm_hw_access.h mpwm_pwm_driver.c
    ../platform/drivers/src/uart/: lin_uart_driver.c lin_uart_driver.h uart_driver.c uart_hw_access.c uart_hw_access.h uart_irq.c uart_irq.h
    ../platform/drivers/src/lin/: lin_common.c lin_driver.c lin_irq.c
  group CMSIS
    ../CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_ccarm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
  group rtos
    ../rtos/osif/: osif.h osif_baremetal.c
  group middleware
    ../middleware/utility_print/printf/: printf.c printf.h
    ../middleware/utility_print/log/: log.c
    ../middleware/utility_print/: log_port.c
    ../middleware/library/Taske/: tt_task.c
    ../middleware/NM/: Nm.c
    ../middleware/NM/CanNm/: CanNm.c CanNm_Autosar.c CanNm_Osek_Direct.c CanNm_Osek_Indirect.c
    ../middleware/NM/Nm_Timer/: Nm_Timer.c
    ../middleware/library/ebtn/: ebtn.c
  group Bsp
    ../Bsp/Hal/bsp_gpio_hal/: bsp_gpio_hal.c
    ../Bsp/Middleware/bsp_gpio_mw/: bsp_gpio_mw.c
    ../Bsp/Hal/bsp_can_hal/: bsp_can_hal.c
    ../Bsp/Middleware/bsp_can_mw/: bsp_can_mw.c
